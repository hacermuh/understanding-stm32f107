# Keil uVision project Http_demo.uvproj, settings and files
target STM3210C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Http_demo +hex
  c flags: Optim=4
  c define: STM3210C
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Files
    ./: HTTP_demo.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Config.c startup_stm32f10x_cl.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib
    ../Library/: ETH_STM32x.c system_stm32f10x_cl.c GLCD.c
  group Documentation
    ./: Abstract.txt
target STM3210C Debug (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM3210C RTX (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c define: RTX_KERNEL
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
