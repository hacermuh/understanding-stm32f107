# Keil uVision project PingEthernet.uvproj, settings and files
target PingEthernet (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: PingEthernet +hex
  c flags: Optim=1
  c include: .\Libraries\Ethernet;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\DeviceSupport\ST\STM32F10x;.\App;.\Drivers
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_stm32f10x_cl.s
  group Libraries
    ./Libraries/Ethernet/: ETH_STM32x.c Net_Config.c
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib
  group Sys
    ./Libraries/CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group App
    ./App/: main.c
